# IAR project GD32C231C_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32C231x8 GD GD32C231x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32C2x1; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pa089,Pe188,Pe236,Pa118,Pe111,Pa084
  ICCARM.CCIncludePath2: ..; ..\GUI_APP; ..\..\Utilities\BSP_Drive; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\m-profile; ..\..\Firmware\CMSIS\GD\GD32C2x1\Include; ..\..\Firmware\CMSIS\GD\GD32C2x1\Source; ..\..\Firmware\CMSIS\GD\GD32C2x1\Source\IAR; ..\..\Firmware\GD32C2x1_Peripherals\Include; ..\..\Utilities\Third_Party\lvgl; ..\..\Utilities\Third_Party\lvgl\port; ..\..\Utilities\Third_Party\lvgl\lvgl_src; ..\..\Utilities\Third_Party\lvgl\lvgl_src\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32C231C_EVAL.srec
  ILINK.IlinkOutputFile: GD32C231C_EVAL.out
  ILINK.IlinkIcfFile: GD32C231x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group Application
    ../: gd32c2x1_it.c main.c systick.c
    ../GUI_APP/: ui.c ui_led_running.c ui_memory_usage.c ui_particle_show.c ui_rgb_wave.c ui_snake.c
  group BSP_Drive
    ../../Utilities/BSP_Drive/: gd32c231c_eval.c lcd_driver.c lv_GPIO_running_LED.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C2x1/Source/: gd32c2x1_err_report.c system_gd32c2x1.c
  group GD32C2x1_standard_peripheral
    ../../Firmware/GD32C2x1_Peripherals/Source/: gd32c2x1_adc.c gd32c2x1_cmp.c gd32c2x1_crc.c gd32c2x1_dbg.c gd32c2x1_dma.c gd32c2x1_exti.c gd32c2x1_fmc.c gd32c2x1_fwdgt.c gd32c2x1_gpio.c gd32c2x1_i2c.c gd32c2x1_misc.c gd32c2x1_pmu.c gd32c2x1_rcu.c gd32c2x1_rtc.c gd32c2x1_spi.c gd32c2x1_syscfg.c gd32c2x1_timer.c gd32c2x1_usart.c gd32c2x1_wwdgt.c
  group lvgl/port
    ../../Utilities/Third_Party/lvgl/port/: lv_port_disp.c
  group lvgl/src/core
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/src/extra
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/: lv_extra.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/freetype/: lv_freetype.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/led/: lv_led.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/list/: lv_list.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/msg/: lv_msg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/span/: lv_span.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/win/: lv_win.c
  group lvgl/src/font
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/src/hal
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group StartUp
    ../../Firmware/CMSIS/GD/GD32C2x1/Source/IAR/: startup_gd32c231_221.s
