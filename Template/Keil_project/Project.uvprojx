# Keil uVision project Project.uvprojx, settings and files
target GD32C231_EVAL (6220000::V6.22::ARMCLANG)
  device: GD32C231C8 GigaDevice
  pack: GigaDevice.GD32C2x1_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0003000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32C231C_EVAL_LVGL_DEMO +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C231,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c include: ..\.;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32C2x1\Include;..\..\Firmware\GD32C2x1_standard_peripheral\Include;..\GUI_APP\ui_lvgl;..\..\Utilities\bsp_drive;..\..\Utilities\lvgl\lvgl;..\..\Utilities\lvgl\lvgl\src;..\..\Utilities\lvgl\lvgl_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application
    ../: gd32c2x1_it.c main.c systick.c
  group Peripherals
    ../../Firmware/GD32C2x1_standard_peripheral/Source/: gd32c2x1_adc.c gd32c2x1_cmp.c gd32c2x1_crc.c gd32c2x1_dbg.c gd32c2x1_dma.c gd32c2x1_exti.c gd32c2x1_fmc.c gd32c2x1_fwdgt.c gd32c2x1_gpio.c gd32c2x1_i2c.c gd32c2x1_misc.c gd32c2x1_pmu.c gd32c2x1_rcu.c gd32c2x1_rtc.c gd32c2x1_spi.c gd32c2x1_syscfg.c gd32c2x1_timer.c gd32c2x1_usart.c gd32c2x1_wwdgt.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C2x1/Source/: gd32c2x1_err_report.c system_gd32c2x1.c
  group Doc
    ../../: README.md
  group Startup
    ../../Firmware/CMSIS/GD/GD32C2x1/Source/ARM/: startup_gd32c231_221.s
  group bsp_drive
    ../../Utilities/bsp_drive/: gd32c231c_eval.c lcd_driver.c lv_GPIO_running_LED.c
  group ui_app
    ../GUI_APP/ui_lvgl/: ui.c ui_led_running.c ui_memory_usage.c ui_particle_show.c ui_rgb_wave.c ui_snake.c
  group lvgl
    ../../Utilities/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Utilities/lvgl/lvgl/src/extra/: lv_extra.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Utilities/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Utilities/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c
software components: CMSIS:CORE 5.5.0
